# IAR project STM32F769I-DISCO.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F769NI ST STM32F769NI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: STM32F769xx; CORE_CM7; USE_HAL_DRIVER
  ICCARM.CCIncludePath2: Source\App; Source\Drivers; Source\Drivers\BSP; Source\Drivers\CMSIS\CMSIS; Source\Drivers\CMSIS\CMSIS\Include; Source\Drivers\CMSIS\Include; Source\Drivers\STM32F7xx_HAL_Driver\Inc; ..\..\..\RTOS\FreeRTOS\FreeRTOSv10.1.1\FreeRTOS\Source\portable\IAR\ARM_CM7\r0p1; Source\FreeRTOS; Source\FreeRTOS\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\RTOS\FreeRTOS\FreeRTOSv10.1.1\FreeRTOS\Source\portable\IAR\ARM_CM7\r0p1; Source\FreeRTOS; Source\FreeRTOS\include
  OBJCOPY.OOCOutputFile: STM32F769.hex
  ILINK.IlinkOutputFile: STM32F769.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ST\stm32f769xI.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group App
    Source/App/: main.c
  group Drivers/BSP
    Source/Drivers/BSP/: bsp.c ft6x06.c isr.c otm8009a.c stm32f769i_discovery.c stm32f769i_discovery_lcd.c stm32f769i_discovery_sdram.c stm32f769i_discovery_ts.c
  group Drivers/CMSIS
    Source/Drivers/CMSIS/CMSIS/: startup_stm32f769xx.s system_stm32f7xx.c
  group Drivers/HAL_Driver
    Source/Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_can.c stm32f7xx_hal_cec.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_cryp.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_dac.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_dcmi.c stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_dfsdm.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_dsi.c stm32f7xx_hal_eth.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hash.c stm32f7xx_hal_hash_ex.c stm32f7xx_hal_hcd.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_i2s.c stm32f7xx_hal_irda.c stm32f7xx_hal_iwdg.c stm32f7xx_hal_jpeg.c stm32f7xx_hal_lptim.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_mdios.c stm32f7xx_hal_mmc.c stm32f7xx_hal_msp_template.c stm32f7xx_hal_nand.c stm32f7xx_hal_nor.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_smartcard.c stm32f7xx_hal_smartcard_ex.c stm32f7xx_hal_smbus.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_spi.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_timebase_rtc_alarm_template.c stm32f7xx_hal_timebase_rtc_wakeup_template.c stm32f7xx_hal_timebase_tim_template.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_hal_wwdg.c stm32f7xx_ll_adc.c stm32f7xx_ll_crc.c stm32f7xx_ll_dac.c stm32f7xx_ll_dma.c stm32f7xx_ll_dma2d.c stm32f7xx_ll_exti.c stm32f7xx_ll_fmc.c stm32f7xx_ll_gpio.c stm32f7xx_ll_i2c.c stm32f7xx_ll_lptim.c stm32f7xx_ll_pwr.c stm32f7xx_ll_rcc.c stm32f7xx_ll_rng.c stm32f7xx_ll_rtc.c stm32f7xx_ll_sdmmc.c stm32f7xx_ll_spi.c stm32f7xx_ll_tim.c stm32f7xx_ll_usart.c stm32f7xx_ll_usb.c stm32f7xx_ll_utils.c
  group FreeRTOS
    Source/FreeRTOS/: event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/Portable
    Source/FreeRTOS/portable/MemMang/: heap_4.c
    Source/FreeRTOS/portable/IAR/ARM_CM7/r0p1/: port.c portasm.s portmacro.h
  group LittlevGL/lv_drivers/display
    Source/lvgl/lv_drivers/display/: stm32.c
  group LittlevGL/lv_drivers/indev
    Source/lvgl/lv_drivers/indev/: touch.c
  group LittlevGL/lv_examples
    Source/lvgl/lv_examples/lv_tests/lv_test_group/: lv_test_group.c
    Source/lvgl/lv_examples/lv_tests/lv_test_obj/: lv_test_obj.c
    Source/lvgl/lv_examples/lv_tests/lv_test_theme/: lv_test_theme.c
  group LittlevGL/lvgl/lv_core
    Source/lvgl/lvgl/lv_core/: lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c lv_vdb.c
  group LittlevGL/lvgl/lv_draw
    Source/lvgl/lvgl/lv_draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_rbasic.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vbasic.c
  group LittlevGL/lvgl/lv_fonts
    Source/lvgl/lvgl/lv_fonts/: lv_font_builtin.c lv_font_dejavu_10.c lv_font_dejavu_10_cyrillic.c lv_font_dejavu_10_latin_sup.c lv_font_dejavu_20.c lv_font_dejavu_20_cyrillic.c lv_font_dejavu_20_latin_sup.c lv_font_dejavu_30.c lv_font_dejavu_30_cyrillic.c lv_font_dejavu_30_latin_sup.c lv_font_dejavu_40.c lv_font_dejavu_40_cyrillic.c lv_font_dejavu_40_latin_sup.c lv_font_monospace_8.c lv_font_symbol_10.c lv_font_symbol_20.c lv_font_symbol_30.c lv_font_symbol_40.c
  group LittlevGL/lvgl/lv_hal
    Source/lvgl/lvgl/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group LittlevGL/lvgl/lv_misc
    Source/lvgl/lvgl/lv_misc/: lv_anim.c lv_area.c lv_circ.c lv_color.c lv_font.c lv_fs.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_task.c lv_templ.c lv_txt.c lv_ufs.c
  group LittlevGL/lvgl/lv_objx
    Source/lvgl/lvgl/lv_objx/: lv_arc.c lv_bar.c lv_btn.c lv_btnm.c lv_calendar.c lv_cb.c lv_chart.c lv_cont.c lv_ddlist.c lv_gauge.c lv_img.c lv_imgbtn.c lv_kb.c lv_label.c lv_led.c lv_line.c lv_list.c lv_lmeter.c lv_mbox.c lv_objx_templ.c lv_page.c lv_preload.c lv_roller.c lv_slider.c lv_sw.c lv_ta.c lv_tabview.c lv_win.c
  group LittlevGL/lvgl/lv_themes
    Source/lvgl/lvgl/lv_themes/: lv_theme.c lv_theme_alien.c lv_theme_default.c lv_theme_material.c lv_theme_mono.c lv_theme_nemo.c lv_theme_night.c lv_theme_templ.c lv_theme_zen.c
